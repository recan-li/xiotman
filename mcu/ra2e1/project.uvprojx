# Keil uVision project project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: R7FA2E1A92DFM Renesas
  pack: Renesas.RA_DFP.3.5.0
  cpu: IRAM(0x20004000,0x004000) IROM(0,0x020000) IROM2(0x40100000,0x001000) IROM3(0x01010000,0x34) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wmissing-declarations  -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: board\ports;..\..\rtos\rt-thread\5.0.x\components\drivers\include;..\..\rtos\rt-thread\5.0.x\libcpu\arm\cortex-m23;.;..\..\rtos\rt-thread\5.0.x\components\libc\compilers\common\extension\fcntl\octal;libraries\HAL_Drivers\config;..\..\rtos\rt-thread\5.0.x\components\libc\posix\io\poll;..\..\rtos\rt-thread\5.0.x\components\libc\compilers\common\extension;..\..\rtos\rt-thread\5.0.x\components\drivers\include;..\..\rtos\rt-thread\5.0.x\components\finsh;..\..\rtos\rt-thread\5.0.x\include;..\..\apps\app_uart_debug\main;..\..\rtos\rt-thread\5.0.x\components\dfs\include;..\..\rtos\rt-thread\5.0.x\components\libc\posix\ipc;ra_cfg\fsp_cfg;board;libraries\HAL_Drivers;ra_cfg\fsp_cfg\bsp;..\..\rtos\rt-thread\5.0.x\components\libc\posix\io\stdio;..\..\rtos\rt-thread\5.0.x\libcpu\arm\common;..\..\rtos\rt-thread\5.0.x\components\drivers\include;..\..\rtos\rt-thread\5.0.x\components\libc\compilers\common\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x40100000 size 0x1000
  memory RVCT9: RAM 0x20004000 size 0x4000
  scatter file: .\script\fsp.scat
  group Compiler
    ../../rtos/rt-thread/5.0.x/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../rtos/rt-thread/5.0.x/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../rtos/rt-thread/5.0.x/libcpu/arm/common/: div0.c showmem.c
    ../../rtos/rt-thread/5.0.x/libcpu/arm/cortex-m23/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../rtos/rt-thread/5.0.x/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../rtos/rt-thread/5.0.x/components/drivers/misc/: pin.c
    ../../rtos/rt-thread/5.0.x/components/drivers/serial/: serial_v2.c
  group Drivers
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_usart_v2.c
  group Filesystem
    ../../rtos/rt-thread/5.0.x/components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
  group Finsh
    ../../rtos/rt-thread/5.0.x/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../rtos/rt-thread/5.0.x/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group main
    ../../apps/app_uart_debug/main/: app_main.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c SConscript
software components: Flex Software:RA Configuration 1.0.0
