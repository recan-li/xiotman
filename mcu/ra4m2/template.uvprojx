# Keil uVision project template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: R7FA4M2AD Renesas
  pack: Renesas.RA_DFP.4.1.0
  cpu: IRAM(0x20000000,0x020000) IROM(0x00000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: .\board;..\..\..\components\legacy
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
