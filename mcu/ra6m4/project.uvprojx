# Keil uVision project project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: R7FA6M4AF Renesas
  pack: Renesas.RA_DFP.3.5.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: ..\..\rtos\rt-thread\5.0.x\components\drivers\wlan;..\..\rtos\rt-thread\5.0.x\components\dfs\filesystems\devfs;..\..\rtos\rt-thread\5.0.x\components\drivers\include;..\..\rtos\rt-thread\5.0.x\components\libc\posix\ipc;..\..\rtos\rt-thread\5.0.x\components\libc\compilers\common\extension\fcntl\octal;..\..\rtos\rt-thread\5.0.x\components\net\sal\include;..\..\rtos\rt-thread\5.0.x\components\libc\posix\io\poll;..\..\rtos\rt-thread\5.0.x\components\libc\compilers\common\extension;libraries\HAL_Drivers;..\..\rtos\rt-thread\5.0.x\components\finsh;..\..\rtos\rt-thread\5.0.x\include;packages\rw007-latest\inc;..\..\rtos\rt-thread\5.0.x\components\drivers\include;..\..\rtos\rt-thread\5.0.x\components\drivers\include;..\..\apps\app_uart_debug\main;..\..\rtos\rt-thread\5.0.x\components\net\sal\include\socket;..\..\rtos\rt-thread\5.0.x\components\dfs\include;..\..\rtos\rt-thread\5.0.x\components\net\sal\include\socket\sys_socket;..\..\rtos\rt-thread\5.0.x\components\drivers\include;..\..\rtos\rt-thread\5.0.x\components\net\sal\impl;packages\rw007-latest;..\..\rtos\rt-thread\5.0.x\components\libc\posix\io\stdio;..\..\rtos\rt-thread\5.0.x\libcpu\arm\common;..\..\rtos\rt-thread\5.0.x\components\net\lwip\lwip-2.0.3\src\include\ipv4;..\..\rtos\rt-thread\5.0.x\components\net\lwip\port;..\..\rtos\rt-thread\5.0.x\components\net\lwip\lwip-2.0.3\src\include\netif;..\..\rtos\rt-thread\5.0.x\components\net\lwip\lwip-2.0.3\src\include;..\..\rtos\rt-thread\5.0.x\components\net\sal\include\dfs_net;..\..\rtos\rt-thread\5.0.x\components\drivers\spi;..\..\rtos\rt-thread\5.0.x\components\net\netdev\include;..\..\rtos\rt-thread\5.0.x\components\libc\compilers\common\include;libraries\HAL_Drivers\config;board\ports;..\..\rtos\rt-thread\5.0.x\libcpu\arm\cortex-m4;.;board
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\script\fsp.scat
  group Compiler
    ../../rtos/rt-thread/5.0.x/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../rtos/rt-thread/5.0.x/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../rtos/rt-thread/5.0.x/libcpu/arm/common/: div0.c showmem.c
    ../../rtos/rt-thread/5.0.x/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../rtos/rt-thread/5.0.x/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../rtos/rt-thread/5.0.x/components/drivers/misc/: pin.c
    ../../rtos/rt-thread/5.0.x/components/drivers/serial/: serial_v2.c
    ../../rtos/rt-thread/5.0.x/components/drivers/spi/: spi_core.c spi_dev.c
    ../../rtos/rt-thread/5.0.x/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group Drivers
    board/ports/: drv_rw007.c
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_spi.c drv_usart_v2.c
  group Filesystem
    ../../rtos/rt-thread/5.0.x/components/dfs/filesystems/devfs/: devfs.c
    ../../rtos/rt-thread/5.0.x/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../rtos/rt-thread/5.0.x/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../rtos/rt-thread/5.0.x/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group lwIP
    ../../rtos/rt-thread/5.0.x/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../rtos/rt-thread/5.0.x/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../rtos/rt-thread/5.0.x/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../rtos/rt-thread/5.0.x/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../rtos/rt-thread/5.0.x/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../rtos/rt-thread/5.0.x/components/net/lwip/port/: ethernetif.c sys_arch.c
  group main
    ../../apps/app_uart_debug/main/: app_main.c
  group rw007
    packages/rw007-latest/src/: spi_wifi_rw007.c
  group SAL
    ../../rtos/rt-thread/5.0.x/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../rtos/rt-thread/5.0.x/components/net/sal/dfs_net/: dfs_net.c
    ../../rtos/rt-thread/5.0.x/components/net/sal/impl/: af_inet_lwip.c
    ../../rtos/rt-thread/5.0.x/components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../rtos/rt-thread/5.0.x/components/net/sal/src/: sal_socket.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c SConscript
software components: Flex Software:RA Configuration 1.0.0
