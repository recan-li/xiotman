# Keil uVision project project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: R7FA4M2AD Renesas
  pack: Renesas.RA_DFP.3.5.0
  cpu: IRAM(0x20000000,0x020000) IROM(0x00000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: packages\ali-iotkit-v3.0.1\iotkit-embedded\src\mqtt\impl;..\libraries\HAL_Drivers;..\..\..\libcpu\arm\common;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\include;packages\at_device-latest\inc;..\..\..\components\net\sal\include\socket\sys_socket;..\..\..\include;..\..\..\components\libc\posix\io\poll;..\libraries\HAL_Drivers\config;..\..\..\components\drivers\include;..\..\..\components\net\sal\include;..\..\..\components\net\at\at_socket;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\posix\ipc;..\..\..\components\net\sal\impl;packages\ali-iotkit-v3.0.1\iotkit-embedded\src\dev_model;..\..\..\components\net\sal\include\socket;..\..\..\components\finsh;..\..\..\components\libc\posix\io\stdio;packages\cJSON-latest;packages\ali-iotkit-v3.0.1\iotkit-embedded\src\mqtt;packages\ali-iotkit-v3.0.1\iotkit-embedded\src\infra;..\..\..\components\dfs\include;..\..\..\components\drivers\include;packages\ali-iotkit-v3.0.1\iotkit-embedded\wrappers;..\..\..\components\dfs\filesystems\devfs;board\ports;..\..\..\components\libc\compilers\common\include;..\..\..\components\net\sal\include\dfs_net;.;..\..\..\libcpu\arm\cortex-m4;packages\at_device-latest\class\esp8266;packages\ali-iotkit-v3.0.1\iotkit-embedded\src\dev_sign;..\..\..\components\libc\compilers\common\extension\fcntl\octal;packages\ali-iotkit-v3.0.1\iotkit-embedded\src\dev_model\server;.\board;..\..\..\components\legacy;..\..\..\components\net\netdev\include;..\..\..\components\net\at\include;packages\ali-iotkit-v3.0.1\iotkit-embedded\src\dev_model\client;..\..\..\components\drivers\include\drivers;.\app
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\script\fsp.scat
  group ali-iotkit
    packages/ali-iotkit-v3.0.1/iotkit-embedded/src/dev_model/: dm_cota.c dm_message.c dm_utils.c dm_ipc.c dm_fota.c dm_ota.c dm_api.c iotx_cm_mqtt.c impl_linkkit.c dm_log_report.c dm_message_cache.c iotx_cm.c dm_msg_process.c dm_opt.c dm_manager.c
    packages/ali-iotkit-v3.0.1/ports/rtthread/: HAL_UDP_rtthread.c HAL_TCP_rtthread.c HAL_OS_rtthread.c
    packages/ali-iotkit-v3.0.1/iotkit-embedded/src/mqtt/impl/: MQTTPacket.c MQTTDeserializePublish.c MQTTSerializePublish.c MQTTUnsubscribeClient.c MQTTSubscribeClient.c iotx_mqtt_client.c MQTTConnectClient.c
    packages/ali-iotkit-v3.0.1/iotkit-embedded/src/infra/: infra_defs.c infra_prt_nwk_payload.c infra_net.c infra_sha256.c infra_cjson.c infra_timer.c infra_string.c infra_report.c infra_compat.c infra_log.c
    packages/ali-iotkit-v3.0.1/samples/mqtt/: mqtt-example.c
    packages/ali-iotkit-v3.0.1/iotkit-embedded/src/mqtt/: mqtt_api.c
    packages/ali-iotkit-v3.0.1/iotkit-embedded/src/dev_sign/: dev_sign_mqtt.c
    packages/ali-iotkit-v3.0.1/iotkit-embedded/src/dev_model/client/: dm_client_adapter.c dm_client.c
    packages/ali-iotkit-v3.0.1/ports/: wrapper.c
  group AT
    ../../../components/net/at/src/: at_utils.c at_client.c at_cli.c
    ../../../components/net/at/at_socket/: at_socket.c
  group at_device
    packages/at_device-latest/class/esp8266/: at_device_esp8266.c at_socket_esp8266.c
    packages/at_device-latest/src/: at_device.c
    packages/at_device-latest/samples/: at_sample_esp8266.c
  group cJSON
    packages/cJSON-latest/: cJSON_Utils.c cJSON.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial_v2.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c spi_msd.c
  group Drivers
    ../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_usart_v2.c
  group Filesystem
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
  group POSIX
    ../../../components/libc/posix/io/poll/: poll.c select.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../components/net/sal/impl/: af_inet_at.c
    ../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal/src/: sal_socket.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.cpp
  group App
    ./app/: i2c_aht25.c i2c_oled.c gpio_light.c smart_room.c uart_nec_ac.c wifi.c
software components: Flex Software:RA Configuration 1.0.0
